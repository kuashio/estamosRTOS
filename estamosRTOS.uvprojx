# Keil uVision project estamosRTOS.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F303K8 STMicroelectronics
  pack: Keil.STM32F3xx_DFP.1.4.0
  cpu: IRAM(0x20000000,0x00003000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: estamosRTOS
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: MCU_STM32F303X8 ESTAMOSRTOS_LOGIC_ANALYZER
  asm misc: --cpreproc
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x3000
  group src
    ./: main.c estamosRTOS.c estamosRTOS.h estamosRTOS_asm.S estamosRTOS_MCU.h
software components: CMSIS:CORE 5.0.1, Device:Startup 1.3.0
